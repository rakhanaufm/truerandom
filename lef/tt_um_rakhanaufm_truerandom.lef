MACRO VCO
  CLASS BLOCK ;
  FOREIGN VCO ;
  ORIGIN -5.900 3.700 ;
  SIZE 23.700 BY 14.390 ;
  OBS
      LAYER nwell ;
        RECT 7.400 -3.700 28.460 10.690 ;
      LAYER li1 ;
        RECT 7.580 -3.520 28.280 10.510 ;
      LAYER met1 ;
        RECT 5.900 -3.300 29.600 10.070 ;
      LAYER met2 ;
        RECT 8.000 -2.550 28.100 9.250 ;
  END
END VCO
END LIBRARY

