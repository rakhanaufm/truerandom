v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -370 -20 -340 -20 {lab=VDPWR}
N -370 -20 -370 220 {lab=VDPWR}
N -370 220 -340 220 {lab=VDPWR}
N -370 140 -340 140 {lab=VDPWR}
N -370 60 -340 60 {lab=VDPWR}
N -400 100 -340 100 {lab=VGND}
N -400 20 -400 100 {lab=VGND}
N -400 20 -340 20 {lab=VGND}
N -400 100 -400 260 {lab=VGND}
N -400 260 -340 260 {lab=VGND}
N -400 180 -340 180 {lab=VGND}
N -430 80 -340 80 {lab=ua[0]}
N -430 80 -430 240 {lab=ua[0]}
N -430 240 -340 240 {lab=ua[0]}
N -430 160 -340 160 {lab=ua[0]}
N -430 0 -430 70 {lab=ua[0]}
N -430 0 -340 0 {lab=ua[0]}
N -430 70 -430 80 {lab=ua[0]}
N 350 160 370 160 {lab=VDPWR}
N 350 0 350 160 {lab=VDPWR}
N 350 0 370 0 {lab=VDPWR}
N 330 0 330 20 {lab=#net1}
N 330 20 370 20 {lab=#net1}
N 330 40 370 40 {lab=#net2}
N 360 60 370 60 {lab=VGND}
N 360 60 360 220 {lab=VGND}
N 360 220 370 220 {lab=VGND}
N 330 200 370 200 {lab=#net3}
N 340 180 370 180 {lab=#net4}
N -400 40 -10 40 {lab=VGND}
N 670 100 670 160 {lab=#net5}
N 670 100 700 100 {lab=#net5}
N 670 80 700 80 {lab=#net6}
N 670 0 670 80 {lab=#net6}
N 370 -30 700 -30 {lab=VDPWR}
N 370 -30 370 0 {lab=VDPWR}
N 370 260 700 260 {lab=VGND}
N 370 220 370 260 {lab=VGND}
N 1060 480 1060 520 {lab=ua[1]}
N -40 -20 -40 0 {lab=#net7}
N -40 0 -10 0 {lab=#net7}
N -10 -40 -10 -20 {lab=VDPWR}
N -340 -40 -10 -40 {lab=VDPWR}
N -340 -40 -340 -20 {lab=VDPWR}
N -40 220 -30 220 {lab=#net8}
N -30 220 -30 240 {lab=#net8}
N -30 240 -10 240 {lab=#net8}
N -40 140 -30 140 {lab=#net9}
N -30 140 -30 160 {lab=#net9}
N -30 160 -10 160 {lab=#net9}
N -40 60 -30 60 {lab=#net10}
N -30 60 -30 80 {lab=#net10}
N -30 80 -10 80 {lab=#net10}
N -10 40 310 40 {lab=VGND}
N 310 40 310 110 {lab=VGND}
N 310 110 360 110 {lab=VGND}
N -50 100 -10 100 {lab=VGND}
N -50 40 -50 100 {lab=VGND}
N -10 20 -10 40 {lab=VGND}
N -50 180 -10 180 {lab=VGND}
N -50 100 -50 180 {lab=VGND}
N -50 260 -20 260 {lab=VGND}
N -50 180 -50 260 {lab=VGND}
N -20 260 -10 260 {lab=VGND}
N -20 220 -10 220 {lab=VDPWR}
N -20 -40 -20 220 {lab=VDPWR}
N -20 60 -10 60 {lab=VDPWR}
N -20 140 -10 140 {lab=VDPWR}
N 290 200 290 220 {lab=#net3}
N 290 200 330 200 {lab=#net3}
N 290 180 340 180 {lab=#net4}
N 290 140 290 180 {lab=#net4}
N 290 60 330 60 {lab=#net2}
N 330 40 330 60 {lab=#net2}
N 330 -20 330 -0 {lab=#net1}
N 290 -20 330 -20 {lab=#net1}
N 370 -50 370 -30 {lab=VDPWR}
N -10 -50 370 -50 {lab=VDPWR}
N -10 -50 -10 -40 {lab=VDPWR}
N 700 120 700 260 {lab=VGND}
N 700 -30 700 50 {lab=VDPWR}
N 700 0 1020 -0 {lab=VDPWR}
N 1080 120 1080 150 {lab=VGND}
N 700 50 700 60 {lab=VDPWR}
N 1040 60 1040 150 {lab=#net11}
N 1000 60 1040 60 {lab=#net11}
N 2440 -20 2470 -20 {lab=VDPWR}
N 2470 -20 2470 220 {lab=VDPWR}
N 2440 220 2470 220 {lab=VDPWR}
N 2440 140 2470 140 {lab=VDPWR}
N 2440 60 2470 60 {lab=VDPWR}
N 2440 100 2500 100 {lab=VGND}
N 2500 20 2500 100 {lab=VGND}
N 2440 20 2500 20 {lab=VGND}
N 2500 100 2500 260 {lab=VGND}
N 2440 260 2500 260 {lab=VGND}
N 2440 180 2500 180 {lab=VGND}
N 2440 80 2530 80 {lab=ua[0]}
N 2530 80 2530 240 {lab=ua[0]}
N 2440 240 2530 240 {lab=ua[0]}
N 2440 160 2530 160 {lab=ua[0]}
N 2530 0 2530 70 {lab=ua[0]}
N 2440 0 2530 0 {lab=ua[0]}
N 2530 70 2530 80 {lab=ua[0]}
N 1730 160 1750 160 {lab=VDPWR}
N 1750 0 1750 160 {lab=VDPWR}
N 1730 0 1750 0 {lab=VDPWR}
N 1770 0 1770 20 {lab=#net12}
N 1730 20 1770 20 {lab=#net12}
N 1730 40 1770 40 {lab=#net13}
N 1730 60 1740 60 {lab=VGND}
N 1740 60 1740 220 {lab=VGND}
N 1730 220 1740 220 {lab=VGND}
N 1730 200 1770 200 {lab=#net14}
N 1730 180 1760 180 {lab=#net15}
N 2110 40 2500 40 {lab=VGND}
N 1430 100 1430 160 {lab=#net16}
N 1400 100 1430 100 {lab=#net16}
N 1400 80 1430 80 {lab=#net17}
N 1430 0 1430 80 {lab=#net17}
N 1400 -30 1730 -30 {lab=VDPWR}
N 1730 -30 1730 0 {lab=VDPWR}
N 1400 260 1730 260 {lab=VGND}
N 1730 220 1730 260 {lab=VGND}
N 2140 -20 2140 0 {lab=#net18}
N 2110 0 2140 0 {lab=#net18}
N 2110 -40 2110 -20 {lab=VDPWR}
N 2110 -40 2440 -40 {lab=VDPWR}
N 2440 -40 2440 -20 {lab=VDPWR}
N 2130 220 2140 220 {lab=#net19}
N 2130 220 2130 240 {lab=#net19}
N 2110 240 2130 240 {lab=#net19}
N 2130 140 2140 140 {lab=#net20}
N 2130 140 2130 160 {lab=#net20}
N 2110 160 2130 160 {lab=#net20}
N 2130 60 2140 60 {lab=#net21}
N 2130 60 2130 80 {lab=#net21}
N 2110 80 2130 80 {lab=#net21}
N 1790 40 2110 40 {lab=VGND}
N 1790 40 1790 110 {lab=VGND}
N 1740 110 1790 110 {lab=VGND}
N 2110 100 2150 100 {lab=VGND}
N 2150 40 2150 100 {lab=VGND}
N 2110 20 2110 40 {lab=VGND}
N 2110 180 2150 180 {lab=VGND}
N 2150 100 2150 180 {lab=VGND}
N 2120 260 2150 260 {lab=VGND}
N 2150 180 2150 260 {lab=VGND}
N 2110 260 2120 260 {lab=VGND}
N 2110 220 2120 220 {lab=VDPWR}
N 2120 -40 2120 220 {lab=VDPWR}
N 2110 60 2120 60 {lab=VDPWR}
N 2110 140 2120 140 {lab=VDPWR}
N 1810 200 1810 220 {lab=#net14}
N 1770 200 1810 200 {lab=#net14}
N 1760 180 1810 180 {lab=#net15}
N 1810 140 1810 180 {lab=#net15}
N 1770 60 1810 60 {lab=#net13}
N 1770 40 1770 60 {lab=#net13}
N 1770 -20 1770 0 {lab=#net12}
N 1770 -20 1810 -20 {lab=#net12}
N 1730 -50 1730 -30 {lab=VDPWR}
N 1730 -50 2110 -50 {lab=VDPWR}
N 2110 -50 2110 -40 {lab=VDPWR}
N 1400 120 1400 260 {lab=VGND}
N 1400 -30 1400 50 {lab=VDPWR}
N 1080 0 1400 0 {lab=VDPWR}
N 1020 120 1020 150 {lab=VDPWR}
N 1260 120 1260 150 {lab=VGND}
N 1260 150 1400 150 {lab=VGND}
N 1400 50 1400 60 {lab=VDPWR}
N 1060 60 1060 150 {lab=#net22}
N 1060 60 1100 60 {lab=#net22}
N 700 260 1400 260 {lab=VGND}
N 1080 120 1260 120 {lab=VGND}
N 1020 0 1020 120 {lab=VDPWR}
N 1020 -0 1080 -0 {lab=VDPWR}
N 2530 -100 2530 0 {lab=ua[0]}
N -390 -100 2530 -100 {lab=ua[0]}
N -390 -100 -390 -0 {lab=ua[0]}
N 1060 450 1060 480 {lab=ua[1]}
N 1020 450 1060 450 {lab=ua[1]}
N 1080 520 1140 520 {lab=ua[0]}
N 1140 -100 1140 520 {lab=ua[0]}
N 970 520 1020 520 {lab=VGND}
N 970 260 970 520 {lab=VGND}
C {/home/Rodin/codes/analogic/500pll/VCO.sym} -190 0 0 0 {name=x1}
C {/home/Rodin/codes/analogic/500pll/VCO.sym} -190 80 0 0 {name=x2}
C {/home/Rodin/codes/analogic/500pll/VCO.sym} -190 160 0 0 {name=x3}
C {/home/Rodin/codes/analogic/500pll/VCO.sym} -190 240 0 0 {name=x4}
C {/home/Rodin/codes/analogic/500pll/XOR.sym} 520 30 0 0 {name=x9}
C {/home/Rodin/codes/analogic/500pll/XOR.sym} 520 190 0 0 {name=x10}
C {/home/Rodin/codes/analogic/500pll/XOR.sym} 850 90 0 0 {name=x14}
C {/home/Rodin/codes/analogic/500pll/DFLIPFLOP.sym} 1050 670 1 0 {name=x15}
C {/home/Rodin/codes/analogic/500pll/XOR.sym} 1050 300 3 1 {name=x16}
C {ipin.sym} 1040 520 1 0 {name=p1 lab=ua[3]}
C {ipin.sym} -430 0 1 0 {name=p2 lab=ua[0]}
C {ipin.sym} -370 -20 1 0 {name=p3 lab=VDPWR}
C {ipin.sym} -400 260 3 0 {name=p4 lab=VGND}
C {opin.sym} 1060 480 0 0 {name=p5 lab=ua[1]}
C {opin.sym} 1080 820 0 0 {name=p6 lab=ua[2]}
C {/home/Rodin/codes/analogic/500pll/BUFFER.sym} 140 0 0 0 {name=x17}
C {/home/Rodin/codes/analogic/500pll/BUFFER.sym} 140 80 0 0 {name=x18}
C {/home/Rodin/codes/analogic/500pll/BUFFER.sym} 140 160 0 0 {name=x19}
C {/home/Rodin/codes/analogic/500pll/BUFFER.sym} 140 240 0 0 {name=x20}
C {/home/Rodin/codes/analogic/500pll/VCO.sym} 2290 0 0 1 {name=x5}
C {/home/Rodin/codes/analogic/500pll/VCO.sym} 2290 80 0 1 {name=x6}
C {/home/Rodin/codes/analogic/500pll/VCO.sym} 2290 160 0 1 {name=x7}
C {/home/Rodin/codes/analogic/500pll/VCO.sym} 2290 240 0 1 {name=x8}
C {/home/Rodin/codes/analogic/500pll/XOR.sym} 1580 30 0 1 {name=x11}
C {/home/Rodin/codes/analogic/500pll/XOR.sym} 1580 190 0 1 {name=x12}
C {/home/Rodin/codes/analogic/500pll/XOR.sym} 1250 90 0 1 {name=x13}
C {/home/Rodin/codes/analogic/500pll/BUFFER.sym} 1960 0 0 1 {name=x21}
C {/home/Rodin/codes/analogic/500pll/BUFFER.sym} 1960 80 0 1 {name=x22}
C {/home/Rodin/codes/analogic/500pll/BUFFER.sym} 1960 160 0 1 {name=x23}
C {/home/Rodin/codes/analogic/500pll/BUFFER.sym} 1960 240 0 1 {name=x24}
